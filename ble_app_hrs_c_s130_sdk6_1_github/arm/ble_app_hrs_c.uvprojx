# Keil uVision project ble_app_hrs_c.uvprojx, settings and files
target nrf51822_xxaa_s120 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.7.0.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ble_app_hrs_c +hex
  c flags: Optim=1 uC99=1
  c define: NRF51 DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD BOARD_PCA10001 ENABLE_DEBUG_LOG_SUPPORT
  c include: ..;..\..\..\..\..\Include;..\..\..\..\..\Include\app_common;..\Include_s130\ble;..\Include_s130\ble\device_manager;..\Include_s130\ble\ble_services;..\..\..\..\..\Include\s130;..\..\..\..\..\include\boards;..\..\..\..\..\include\sd_common;..\..\..\..\..\Include\ext_sensors;..\..\..\..\..\Include\sdk;..\inc_s130;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\ble
  library: MicroLIB
  memory RVCT4: ROM 0x1c000 size 0x24000
  memory RVCT9: RAM 0x20002800 size 0x1800
  group ::Device
    RTE/Device/nRF51822_xxAA/: arm_startup_nrf51.s system_nrf51.c
    RTE/Device/nRF51822_xxAB/: arm_startup_nrf51.s system_nrf51.c
  group Source Code
    ./../: main.c
    ../: ble_broadcaster.c ble_observer.c
  group Services
    ../Source_s130/ble/ble_services/: ble_hrs_c.c ble_bas_c.c ble_bas.c ble_dis.c ble_hrs.c
  group Libraries
    ../../../../../Source/ble/: ble_debug_assert_handler.c ble_advdata.c
    ../../../../../Source/app_common/: app_trace.c pstorage.c app_button.c app_gpiote.c app_timer.c
    ../../../../../Source/simple_uart/: simple_uart.c
    ../Source_s130/ble/: ble_db_discovery.c ble_conn_params.c
    ../../../../../Source/ext_sensors/nRF6350/: nRF6350.c
    ../../../../../Source/twi_master/: twi_hw_master.c
    ../Source_s130/ble/device_manager/: device_manager_central.c
    ../../../../../Source/sd_common/: softdevice_handler.c
    ../../../../../Source/ble/ble_services/: ble_srv_common.c
    ../../../../..//Source/ble/: ble_sensorsim.c
target nrf51822_xxab_s120 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.7.0.0
  cpu: as above
  output: ble_app_hrs_c +hex
  c flags: Optim=1 uC99=1
  c define: NRF51 DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD BOARD_NRF6310 ENABLE_DEBUG_LOG_SUPPORT
  c include: ..;..\..\..\..\..\Include;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\device_manager;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\s120;..\..\..\..\..\include\boards;..\..\..\..\..\include\sd_common;..\..\..\..\..\Include\ext_sensors;..\..\..\..\..\Include\sdk
  memory RVCT4: ROM 0x18000 size 0x7000
  memory RVCT9: RAM 0x20002800 size 0x1800
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.1
